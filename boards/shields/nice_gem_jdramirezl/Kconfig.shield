## boards/shields/nice_gem_jdramirezl/Kconfig.shield
```kconfig
config SHIELD_NICE_GEM_JDRAMIREZL
def_bool $(shields_list_contains,nice_gem_jdramirezl)
```
